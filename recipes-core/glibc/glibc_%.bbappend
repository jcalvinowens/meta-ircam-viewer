FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"
SRC_URI += "file://0001-math-Fix-x86_64-build-for-Os-BZ-33367.patch"
