PACKAGECONFIG:remove = "sdl slirp"
