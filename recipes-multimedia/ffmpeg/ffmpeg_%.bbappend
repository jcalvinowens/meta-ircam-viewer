PACKAGECONFIG:append = " avcodec avformat"
PACKAGECONFIG:remove = " \
	avdevice \
	avfilter \
	swresample \
	swscale \
	postproc \
	\
	alsa \
	altivec \
	bzlib \
	fdk-aac \
	gpl \
	gsm \
	jack \
	libopus \
	libvorbis \
	lzma \
	mfx \
	mp3lame \
	openssl \
	sdl2 \
	speex \
	srt \
	theora \
	v4l2 \
	vaapi \
	vdpau \
	vpx \
	x264 \
	x265 \
	xcb \
	xv \
	zlib \
	"
