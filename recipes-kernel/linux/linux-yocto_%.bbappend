FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:beaglebone-yocto = " file://uvcvideo.cfg"
